# Keil uVision project first_demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: first_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 led.c digital_tube.c digital_tube.h led.h main.c key_led.c key_led.h matrix_key.c matrix_key.h
